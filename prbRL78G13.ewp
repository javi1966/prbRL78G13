# IAR project prbRL78G13.ewp, settings and files
configuration Debug (RL78, debug)
  General.GenDeviceSelect: R5F100LE RL78 - R5F100LE
  General.GenCodeModel: 0
  General.GenDataModel: 0
  General.GenStackSize: 1024
  General.GenNearHeapSize: 256
  General.GenFarHeapSize: 4096
  ICCRL78.IccLang: 0
  ICCRL78.CCIncludePath2: user_include\
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnkr5f100le.xcl
  XLINK.XlinkStackSize: 1
configuration Release (RL78)
  as the first configuration, except:
  General.GenStackSize: 256
  ICCRL78.CCDefines: NDEBUG
  group (top)
    ./: delay.c delay.h intrinsics.h ior5f100le.h ior5f100le_ext.h IR.c IR.h lcd.c lcd.h main.c RTC.c RTC.h spi.c spi.h
  group Fonts
    Fonts/: bitmap_font.c font_8x16.c font_8x8.c font_helvr10.c font_logos.c font_winfreesystem14x16.c font_x5x7.c font_x6x13.c
